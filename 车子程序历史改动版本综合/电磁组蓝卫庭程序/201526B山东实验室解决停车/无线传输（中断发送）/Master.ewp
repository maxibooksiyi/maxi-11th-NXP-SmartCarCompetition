# IAR project Master.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: IAR; DEBUG; TWR_K60N512; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\无线传输（中断发送）\src\LIB\CMSIS; ..\无线传输（中断发送）\src\LIB\FatFs; ..\无线传输（中断发送）\src\app; ..\无线传输（中断发送）\src\common; ..\无线传输（中断发送）\src\cpu; ..\无线传输（中断发送）\src\cpu\headers; ..\无线传输（中断发送）\src\platforms; ..\无线传输（中断发送）\src\drivers; ..\无线传输（中断发送）\src\drivers\adc; ..\无线传输（中断发送）\src\drivers\dac; ..\无线传输（中断发送）\src\drivers\abs; ..\无线传输（中断发送）\src\drivers\key; ..\无线传输（中断发送）\src\drivers\control; ..\无线传输（中断发送）\src\drivers\OLED; ..\无线传输（中断发送）\src\drivers\exti; ..\无线传输（中断发送）\src\drivers\delay; ..\无线传输（中断发送）\src\drivers\dma; ..\无线传输（中断发送）\src\drivers\FTM; ..\无线传输（中断发送）\src\drivers\gpio; ..\无线传输（中断发送）\src\drivers\i2c; ..\无线传输（中断发送）\src\drivers\LED; ..\无线传输（中断发送）\src\drivers\lptmr; ..\无线传输（中断发送）\src\drivers\mcg; ..\无线传输（中断发送）\src\drivers\PIT; ..\无线传输（中断发送）\src\drivers\pmc; ..\无线传输（中断发送）\src\drivers\sdhc; ..\无线传输（中断发送）\src\drivers\spi; ..\无线传输（中断发送）\src\drivers\rtc; ..\无线传输（中断发送）\src\drivers\uart; ..\无线传输（中断发送）\src\drivers\wdog; ..\无线传输（中断发送）\src\drivers\flash; ..\无线传输（中断发送）\src\drivers\NRF24L0; ..\无线传输（中断发送）\src; ..\无线传输（中断发送）\build; mycar\无线传输（中断发送）\config files; ..\无线传输（中断发送）\src\user
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fire_gpio_demo.hex
  ILINK.IlinkOutputFile: fire_gpio_demo.out
  ILINK.IlinkIcfFile: F:\mycar\第十届电磁（发送）\icf\fire_RAM_K60N512.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  ICCARM.CCDefines: NDEBUG; IAR; TWR_K60N512; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\无线传输（中断发送）\src\LIB\CMSIS; ..\无线传输（中断发送）\src\LIB\FatFs; ..\无线传输（中断发送）\src\app; ..\无线传输（中断发送）\src\common; ..\无线传输（中断发送）\src\cpu; ..\无线传输（中断发送）\src\cpu\headers; ..\无线传输（中断发送）\src\platforms; ..\无线传输（中断发送）\src\drivers; ..\无线传输（中断发送）\src\drivers\adc; ..\无线传输（中断发送）\src\drivers\mpu6050; ..\无线传输（中断发送）\src\drivers\key; ..\无线传输（中断发送）\src\drivers\control; ..\无线传输（中断发送）\src\drivers\OLED; ..\无线传输（中断发送）\src\drivers\exti; ..\无线传输（中断发送）\src\drivers\dma; ..\无线传输（中断发送）\src\drivers\FTM; ..\无线传输（中断发送）\src\drivers\gpio; ..\无线传输（中断发送）\src\drivers\i2c; ..\无线传输（中断发送）\src\drivers\NRF24L01; ..\无线传输（中断发送）\src\drivers\lptmr; ..\无线传输（中断发送）\src\drivers\mcg; ..\无线传输（中断发送）\src\drivers\PIT; ..\无线传输（中断发送）\src\drivers\pmc; ..\无线传输（中断发送）\src\drivers\sdhc; ..\无线传输（中断发送）\src\drivers\spi; ..\无线传输（中断发送）\src\drivers\rtc; ..\无线传输（中断发送）\src\drivers\znfat; ..\无线传输（中断发送）\src\drivers\uart; ..\无线传输（中断发送）\src\drivers\wdog; ..\无线传输（中断发送）\src\drivers\flash; ..\无线传输（中断发送）\src; ..\无线传输（中断发送）\build; mycar\无线传输（中断发送）\config files; ..\无线传输（中断发送）\src\user
  ICCARM.CCOptLevel: 1
  ICCARM.IccLang: 2
  ILINK.IlinkIcfFile: F:\mycar\2015720前通信\无线传输（中断发送）\config files\256KB_Pflash_256KB_Dflash.icf
  group app
    src/app/: isr.c isr.h
  group common
    src/common/: alloc.c assert.c io.c memtest.c printf.c queue.c startup.c stdlib.c uif.c
  group cpu
    src/cpu/: arm_cm4.c crt0.s start.c sysinit.c vectors.c
  group drivers/adc
    src/drivers/adc/: adc.c adc.h adc_cfg.h
  group drivers/dma
    src/drivers/dma/: dma.c dma.h
  group drivers/exti
    src/drivers/exti/: exti.c exti.h
  group drivers/flash
    src/drivers/Flash/: flash.c flash.h
  group drivers/FTM
    src/drivers/FTM/: FTM.c FTM.h
  group drivers/gpio
    src/drivers/gpio/: gpio.c gpio.h gpio_cfg.h
  group drivers/IIC
    src/drivers/i2c/: i2c.c i2c.h i2c_cfg.h
  group drivers/lptmr
    src/drivers/lptmr/: lptmr.c lptmr.h
  group drivers/mcg
    src/drivers/mcg/: Fire_kinetis_MCG_CFG.h mcg.c mcg.h mcg_cfg.h
  group drivers/NRF24L01
    src/drivers/NRF24L01/: NRF24L0.c NRF24L0.h
  group drivers/OLED
    src/drivers/OLED/: OLED.c OLED.h
  group drivers/PIT
    src/drivers/PIT/: PIT.c PIT.h
  group drivers/sdhc
    src/drivers/sdhc/: sdhc.c sdhc.h
  group drivers/spi
    src/drivers/spi/: spi.c spi.h
  group drivers/uart
    src/drivers/uart/: uart.c uart.h
  group drivers/wdog
    src/drivers/wdog/: wdog.c wdog.h
  group FatFs
    src/LIB/FatFs/: diskio.c diskio.h ff.c ff.h
  group header
    src/common/: common.h
    src/drivers/: fire_drivers_cfg.h
    src/app/: include.h
    src/platforms/: k60_fire.h
  group icf
    icf/: 128KB_Ram.icf 256KB_Pflash_256KB_Dflash.icf 512KB_Pflash.icf fire_RAM_K60N512.icf fire_ROM_K60N512.icf
  group user
    src/drivers/control/: control.c control.h
    src/user/: Data_send.c Data_send.h flag.h main.c
    src/drivers/: define.h
